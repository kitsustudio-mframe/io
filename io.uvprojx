# Keil uVision project io.uvprojx, settings and files
target cm0 (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: io_cm0 (library)
  AfterMake: cmd.exe /C copy .keil\cm0\Objects\io_cm0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: Buffer.h ByteBuffer.cpp ByteBuffer.h Closeable.h EmptyReadBuffer.cpp EmptyReadBuffer.h EmptyWriteBuffer.cpp EmptyWriteBuffer.h InputStream.cpp InputStream.h InputStreamBuffer.cpp InputStreamBuffer.h OutputStream.cpp OutputStream.h OutputStreamBuffer.cpp OutputStreamBuffer.h package-info.h PrintBuffer.cpp PrintBuffer.h README.md ReadOnlyBuffer.cpp ReadOnlyBuffer.h RingBuffer.cpp RingBuffer.h StreamSkipper.cpp StreamSkipper.h WriteBuffer.h
target cm3 (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: io_cm3 (library)
  AfterMake: cmd.exe /C copy .keil\cm3\Objects\io_cm3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cm4f (6160000::V6.16::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: io_cm4f (library)
  AfterMake: cmd.exe /C copy .keil\cm4f\Objects\io_cm4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
